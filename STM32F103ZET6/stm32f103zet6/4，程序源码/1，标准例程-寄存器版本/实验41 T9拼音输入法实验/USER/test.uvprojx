# Keil uVision project test.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: test +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\LED;..\HARDWARE\BEEP;..\HARDWARE\KEY;..\HARDWARE\EXTI;..\HARDWARE\WDG;..\HARDWARE\TIMER;..\HARDWARE\TPAD;..\HARDWARE\OLED;..\HARDWARE\LCD;..\HARDWARE\RTC;..\HARDWARE\WKUP;..\HARDWARE\ADC;..\HARDWARE\LSENS;..\HARDWARE\DAC;..\HARDWARE\DMA;..\HARDWARE\24CXX;..\HARDWARE\SPI;..\HARDWARE\W25QXX;..\HARDWARE\RS485;..\HARDWARE\CAN;..\HARDWARE\TOUCH;..\HARDWARE\REMOTE;..\HARDWARE\JOYPAD;..\HARDWARE\DS18B20;..\HARDWARE\DHT11;..\HARDWARE\MPU6050;..\HARDWARE\MPU6050\eMPL;..\HARDWARE\NRF24L01;..\HARDWARE\STMFLASH;..\HARDWARE\OV7670;..\HARDWARE\SRAM;..\HARDWARE\SDIO;..\HARDWARE\VS10XX;..\FATFS\src;..\FATFS\exfuns;..\USMART;..\MALLOC;..\TEXT;..\PICTURE;..\APP;..\ATKNCR;..\T9INPUT
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Group 1
    ./: startup_stm32f10x_hd.s
  group USER
    ./: test.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/LCD/: ILI93xx.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/SDIO/: sdio_sdcard.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/W25QXX/: w25qxx.c
    ../HARDWARE/24CXX/: myiic.c 24cxx.c
    ../HARDWARE/TOUCH/: ctiic.c ft5206.c gt9147.c ott2001a.c touch.c
  group MALLOC
    ../MALLOC/: malloc.c
  group FATFS
    ../FATFS/src/: diskio.c ff.c
    ../FATFS/exfuns/: exfuns.c fattester.c mycc936.c
  group TEXT
    ../TEXT/: fontupd.c text.c
  group T9INPUT
    ../T9INPUT/: pyinput.c
  group USMART
    ../USMART/: usmart.c usmart_config.c usmart_str.c
  group README
    ../: README.TXT
