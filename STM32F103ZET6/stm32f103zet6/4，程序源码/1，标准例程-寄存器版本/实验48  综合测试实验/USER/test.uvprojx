# Keil uVision project test.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: test +hex
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\LED;..\HARDWARE\BEEP;..\HARDWARE\KEY;..\HARDWARE\EXTI;..\HARDWARE\WDG;..\HARDWARE\TIMER;..\HARDWARE\TPAD;..\HARDWARE\OLED;..\HARDWARE\LCD;..\HARDWARE\RTC;..\HARDWARE\WKUP;..\HARDWARE\ADC;..\HARDWARE\LSENS;..\HARDWARE\DAC;..\HARDWARE\DMA;..\HARDWARE\24CXX;..\HARDWARE\SPI;..\HARDWARE\W25QXX;..\HARDWARE\RS485;..\HARDWARE\CAN;..\HARDWARE\TOUCH;..\HARDWARE\REMOTE;..\HARDWARE\JOYPAD;..\HARDWARE\DS18B20;..\HARDWARE\DHT11;..\HARDWARE\MPU6050;..\HARDWARE\MPU6050\eMPL;..\HARDWARE\NRF24L01;..\HARDWARE\STMFLASH;..\HARDWARE\OV7725;..\HARDWARE\SRAM;..\HARDWARE\SDIO;..\HARDWARE\SPBLCD;..\HARDWARE\USART3;..\HARDWARE\SIM900A;..\FATFS\src;..\FATFS\exfuns;..\USMART;..\MALLOC;..\TEXT;..\PICTURE;..\APP;..\UCOSII\CORE;..\UCOSII\PORT;..\UCOSII\CONFIG;..\GUI;..\T9INPUT;..\ATKNCR;..\USB\CONFIG;..\USB\STM32_USB-FS-Device_Driver\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Group 1
    ./: startup_stm32f10x_hd.s
  group USER
    ./: test.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/LCD/: ILI93xx.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/SDIO/: sdio_sdcard.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/W25QXX/: w25qxx.c
    ../HARDWARE/SPBLCD/: spblcd.c
    ../HARDWARE/TOUCH/: ctiic.c ft5206.c gt9147.c ott2001a.c touch.c
    ../HARDWARE/24CXX/: 24cxx.c myiic.c
    ../HARDWARE/SIM900A/: sim900a.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/TPAD/: tpad.c
    ../HARDWARE/USART3/: usart3.c
    ../HARDWARE/RTC/: rtc.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/LSENS/: lsens.c
    ../HARDWARE/DS18B20/: ds18b20.c
    ../HARDWARE/BEEP/: beep.c
    ../HARDWARE/NRF24L01/: 24l01.c
    ../HARDWARE/REMOTE/: remote.c
    ../HARDWARE/MPU6050/: mpu6050.c mpuiic.c
    ../HARDWARE/MPU6050/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../HARDWARE/EXTI/: exti.c
    ../HARDWARE/OV7725/: ov7725.c sccb.c
  group USMART
    ../USMART/: usmart.c usmart_config.c usmart_str.c
  group MALLOC
    ../MALLOC/: malloc.c
  group FATFS
    ../FATFS/src/: diskio.c ff.c
    ../FATFS/exfuns/: exfuns.c fattester.c mycc936.c
  group TEXT
    ../TEXT/: fontupd.c text.c
  group PICTURE
    ../PICTURE/: bmp.c gif.c piclib.c tjpgd.c
  group APP
    ../APP/: common.c spb.c ebook.c picviewer.c calendar.c settings.c notepad.c exeplay.c paint.c camera.c usbplay.c wirelessplay.c calculator.c phoneplay.c appplay.c smsplay.c appplay_gyro.c appplay_remote.c
  group GUI
    ../GUI/: button.c edit.c filelistbox.c gui.c listbox.c memo.c progressbar.c scrollbar.c window.c
  group UCOSII-CORE
    ../UCOSII/CORE/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group UCOSII-PORT
    ../UCOSII/PORT/: os_cpu_c.c os_cpu_a.asm os_cpu.h
  group UCOSII-CONFIG
    ../UCOSII/CONFIG/: includes.h os_cfg.h
  group T9INPUT
    ../T9INPUT/: pyinput.c t9input.c
  group ATKNCR
    ../ATKNCR/: atk_ncr.c ATKNCR_M_V2.0.lib
  group USB_CORE
    ../USB/STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group USB_CONFIG
    ../USB/CONFIG/: hw_config.c mass_mal.c memory.c scsi_data.c usb_bot.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c usb_scsi.c
  group README
    ../: README.TXT
